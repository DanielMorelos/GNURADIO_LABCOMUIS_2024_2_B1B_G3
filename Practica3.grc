options:
  parameters:
    author: Daniel Morelos y Hailen Chacón
    generate_options: qt_gui
    id: practica1B
    output_language: python
    title: generador
  states: {}

blocks:
- name: A
  id: variable_qtgui_range
  parameters:
    label: Amplitud señal
    start: '0'
    step: '1e-2'
    stop: '500e-3'
    value: '500e-3'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: Ganancia transmisor
    start: '0'
    step: '500e-3'
    stop: '100'
    value: '500e-3'
  states: {}
- name: 'No'
  id: variable_qtgui_range
  parameters:
    label: Amplitud Ruido
    start: '0'
    step: '1e-6'
    stop: '1e-1'
    value: '1e-4'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: frecuencia portadora
    start: 50e6
    step: 1e5
    stop: 1e9
    value: 200e6
  states: {}
- name: fcut
  id: variable_qtgui_range
  parameters:
    label: frecuencia de corte filtro
    start: '0'
    step: '100'
    stop: samp_rate/2
    value: samp_rate/2
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: Frequencia Señal
    start: 1e3
    step: 1e3
    stop: 1e6
    value: 10e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 25e6/8
  states: {}
- name: t_band
  id: variable_qtgui_range
  parameters:
    label: Bnada de transicion
    start: '0'
    step: '100'
    stop: samp_rate/20
    value: samp_rate/20
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    alias: analog_noise_source_x_0
    amp: 'No'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    alias: analog_sig_source_x_0
    amp: A
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    alias: blocks_add_xx_0
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    alias: blocks_thtottle2_0
    samples_per_second: samp_rate
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    alias: low_pass_filter_0
    cutoff_freq: fcut
    gain: '1'
    interp: '1'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: t_band
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    alias: qtgui_freq_sink_x_0
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    alias: qtgui_time_sink_x_0
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    alias: uhd_usrp_sink_0
    ant0: '"TX/RX"'
    center_freq0: fc
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_throttle2_0, '0']
- [blocks_add_xx_0, '0', low_pass_filter_0, '0']
- [blocks_float_to_complex_0, '0', uhd_usrp_sink_0, '0']
- [blocks_throttle2_0, '0', blocks_add_xx_0, '0']
- [low_pass_filter_0, '0', blocks_float_to_complex_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-810-g1ecb8565
